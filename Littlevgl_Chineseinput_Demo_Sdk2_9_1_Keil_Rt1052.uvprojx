# Keil uVision project Littlevgl_Chineseinput_Demo_Sdk2_9_1_Keil_Rt1052.uvprojx, settings and files
target Littlevgl_Chineseinput_Demo_Sdk2_9_1_Keil_Rt1052 flexspi_nor_sdram_debug (6140000::V6.14::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: Littlevgl_Chineseinput_Demo_Sdk2_9_1_Keil_Rt1052.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, LV_CONF_INCLUDE_SIMPLE=1, LV_EX_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: board;source;CMSIS;component/lists;component/serial_manager;component/uart;device;drivers;freertos/freertos_kernel/include;freertos/freertos_kernel/portable/GCC/ARM_CM4F;littlevgl;littlevgl/lv_examples;littlevgl/lv_examples/src/lv_demo_chineseinpupt;littlevgl/lvgl;littlevgl/lvgl/src;touchpanel;utilities;xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: source
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h littlevgl_support.c littlevgl_support.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h
  group freertos/freertos_kernel
    freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    freertos/freertos_kernel/portable/MemMang/: heap_4.c
  group freertos/freertos_kernel/portable
    freertos/freertos_kernel/portable/: readme.txt
  group littlevgl
    littlevgl/: ChangeLogKSDK.txt
  group littlevgl/lv_examples
    littlevgl/lv_examples/: lv_examples.h
  group littlevgl/lv_examples/src/lv_demo_chineseinput
    ./littlevgl/lv_examples/src/lv_demo_chineseinput/: lv_chs_keyboard.c lv_chs_keyboard.h lv_demo_chineseinput.c lv_demo_chineseinput.h nxp_logo.c qwerty_py.c qwerty_py.h lv_font_NotoSansCJKsc_Regular.c
  group littlevgl/lvgl/examples/porting
    littlevgl/lvgl/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_fs_template.c lv_port_fs_template.h lv_port_indev_template.c lv_port_indev_template.h
  group littlevgl/lvgl
    littlevgl/lvgl/: LICENCE.txt lvgl.h
  group littlevgl/lvgl/src
    littlevgl/lvgl/src/: lv_api_map.h lv_conf_internal.h
  group littlevgl/lvgl/src/lv_core
    littlevgl/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_obj_style_dec.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group littlevgl/lvgl/src/lv_draw
    littlevgl/lvgl/src/lv_draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group littlevgl/lvgl/src/lv_font
    littlevgl/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_symbol_def.h
  group littlevgl/lvgl/src/lv_gpu
    littlevgl/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h lv_gpu_stm32_dma2d.h
  group littlevgl/lvgl/src/lv_hal
    littlevgl/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group littlevgl/lvgl/src/lv_misc
    littlevgl/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_debug.c lv_debug.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group littlevgl/lvgl/src/lv_themes
    littlevgl/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_empty.c lv_theme_empty.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_template.c lv_theme_template.h
  group littlevgl/lvgl/src/lv_widgets
    littlevgl/lvgl/src/lv_widgets/: lv_anim_img.c lv_anim_img.h lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_chart.c lv_chart.h lv_checkbox.c lv_checkbox.h lv_cont.c lv_cont.h lv_cpicker.c lv_cpicker.h lv_dropdown.c lv_dropdown.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_keyboard.c lv_keyboard.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_linemeter.c lv_linemeter.h lv_list.c lv_list.h lv_msgbox.c lv_msgbox.h lv_objmask.c lv_objmask.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_spinner.c lv_spinner.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_textarea.c lv_textarea.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group source
    ./source/: littlevgl_demo_Chinseinput.c
    source/: FreeRTOSConfig.h lv_conf.h lv_ex_conf.h
  group startup
    startup/: startup_MIMXRT1052.S
  group touchpanel
    touchpanel/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
target Littlevgl_Chineseinput_Demo_Sdk2_9_1_Keil_Rt1052 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: Littlevgl_Chineseinput_Demo_Sdk2_9_1_Keil_Rt1052.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1052DVL6B, LV_CONF_INCLUDE_SIMPLE=1, LV_EX_CONF_INCLUDE_SIMPLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: board;source;CMSIS;component/lists;component/serial_manager;component/uart;device;drivers;evkbimxrt1050/littlevgl_examples/littlevgl_demo_widgets;freertos/freertos_kernel/include;freertos/freertos_kernel/portable/GCC/ARM_CM4F;littlevgl;littlevgl/lv_examples;littlevgl/lv_examples/src/lv_demo_widgets;littlevgl/lvgl;littlevgl/lvgl/src;touchpanel;utilities;xip
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: source
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052/arm/MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
--remove
